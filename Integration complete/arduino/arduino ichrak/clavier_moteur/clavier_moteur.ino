#include <Keypad.h>




#include <Servo.h> 
// on inclut la bibliothèque pour piloter un servomoteur

Servo monServo;  // on crée l'objet monServo
char data;


const byte ROWS = 4; //four rows
const byte COLS = 4; //three columns
char keys[ROWS][COLS] = { 
  {'1','2','3','A'},
  {'4','5','6','B'},
  {'7','8','9','C'},
  {'*','0','#','D'}
};

byte rowPins[ROWS] = {2, 3, 4, 5}; //connect to the row pinouts of the keypad
byte colPins[COLS] = {8, 9, 10, 11}; //connect to the column pinouts of the keypad

Keypad keypad = Keypad( makeKeymap(keys), rowPins, colPins, ROWS, COLS );

void setup(){
  Serial.begin(9600);

  monServo.attach(3); // on définit le Pin utilisé par le servomoteur
     monServo.write(0);
}
  
void loop(){
  char key = keypad.getKey();
    // just print the pressed key
   if (key){
    Serial.print(key);
  } 
  
 /* **************Output****************/
 if(Serial.available())
{
  data=Serial.read();
  if(data=='1') // if les  donnee envoyee au arduino egal 1
  {
     for(int i=0;i<4;i++)
   {
   // digitalWrite(LEDR,HIGH);//allumer la led rouge 
     monServo.write(90); //l'aiguille de moteur tourne faire une angle 90°
    delay(500);  //atttend 500s
       
        
            delay(500);

   }

  }
  else if(data=='0')
  {
   // digitalWrite(LEDR,LOW); //desactiver la led rouge 
     monServo.write(150);  //l'aiguille de moteur tourne avec angle 150°
  }
}

    }
